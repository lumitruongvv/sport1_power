# Keil uVision project project_treadmill_power.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: project_treadmill_power +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\Common;..\Driver;..Mid\Irf
  group App
    ../App/: main.c
  group Common
    ../Common/: Function_Define.h N76E003.h SFR_Macro.h
  group Driver
    ../Driver/: adc.c adc.h delay.c delay.h pwm.c pwm.h uart.c uart.h
  group Mid
    ../Mid/Irf/: Irf.c Irf.h
  group Startup
    ../Startup/: STARTUP.A51
